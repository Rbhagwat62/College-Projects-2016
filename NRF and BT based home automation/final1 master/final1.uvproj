# Keil uVision project final1.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: final1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../finaldemo/: delay.c delay.h HRD.h I2C.H RF24.c RF24.h spi.c spi.h USART.c USART.h
    ./: fial.c
